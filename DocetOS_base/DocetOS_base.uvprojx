# Keil uVision project DocetOS_base.uvprojx, settings and files
target STM32F407 Flash (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F407VG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: DocetOS_base
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F407xx,STM32F4XX,HSE_VALUE=8000000,PLL_M=8,PLL_N=336,PLL_P=2,PLL_Q=7,__FILE_INCOMPLETE
  c misc: --c99 --strict_warnings --diag_suppress 667
  c include: .\OS
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group System
    ./utils/: retarget.c serial.c
  group Source Files
    ./: main.c fixedPriorityScheduler.c
  group OS
    ./OS/: os_asm.s os.c
  group Debug
    ./utils/: hardfault.c
  group OS Utilities
    ./: mutex.c sleep.c lists.c semaphore.c
software components: CMSIS:CORE 4.3.0, Device:Startup 2.5.0
